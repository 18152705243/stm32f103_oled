# Keil uVision project stm32f103.uvprojx, settings and files
target stm32f103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\drivers;..\libraries\fwlib\inc;..\libraries\cmsis;..\src;..\bsp;..\oscilloscope
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../src/: main.c stm32f10x_it.c
  group oscilloscope
    ../oscilloscope/: scope.c scope_gui.c scope_conf.h
  group drivers
    ../drivers/: oled.c
  group bsp
    ../bsp/: bsp_config.c bsp_usart.c bsp_timer.c spi.c dma.c bsp_adc.c bsp_gpio.c
  group fwlib
    ../libraries/fwlib/src/: stm32f10x_adc.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c
  group cmsis
    ../libraries/cmsis/: core_cm3.c system_stm32f10x.c
    ../libraries/cmsis/startup/: startup_stm32f10x_md.s
